# Repository semes1/stm32-minsystem

File README.md:

# stm32-minsystem
this is my project templates

## KiCad design F103Vxxx/kicad/stmf103vet6最小系统.kicad_pcb

Parts:
C1, C2, C5, C6: 22Pf; C_0805_2012Metric
C3, C4: 12Pf; C_0805_2012Metric
C7, C9, C10, C12, C14: 104; C_0805_2012Metric
C8: 106; C_0805_2012Metric
C11, C13, C16: 220uF; CP_Radial_D5.0mm_P2.50mm
C15: 680uF; CP_Radial_D8.0mm_P3.50mm
D1: 1N4148; D_SOD-123
D2, D3: SS54; D_SMA
J1: USB_C; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J2: 禁止下载; PinSocket_2x02_P2.54mm_Vertical
J3: Conn_ARM_JTAG_SWD_20; PinSocket_2x10_P2.54mm_Horizontal
J4: PinSocket_2x03_P2.54mm_Vertical
J5: Jack-DC; DC-05-21
J6: SWD; PinSocket_1x05_P2.54mm_Vertical
L1: 33uH; L_6.3x6.3_H3
Q1: S8050; SOT-23
Q2: S8550; SOT-23
R1, R3: 10K; R_0805_2012Metric
R2, R4, R5, R6, R7: 1K; R_0805_2012Metric
SW1: 复位开关; switch4.5mmX6.5mm-4pin
U1: STM32F103VET6; LQFP-100_14x14mm_P0.5mm
U2: CH340G; SOIC-16_3.9x9.9mm_P1.27mm
U3: LM2596S-5; TO-263-5_TabPin3
U4: AMS1117-3.3; SOT-223-3_TabPin2
Y1: 8MHz; Crystal_SMD_HC49-SD
Y2: 32.768KHz; Crystal_C26-LF_D2.1mm_L6.5mm_Horizontal
Y3: 12MHz; Crystal_SMD_HC49-SD

Connections:
+3.3V: C11.1, C14.1, J3.1 (VTREF), J3.2 (VCC/NC), J4.1, J4.2, J6.4, Q2.1 (E), R1.1, R3.2, U1.6 (VBAT), U1.11 (VDD), U1.21 (VREF+), U1.22 (VDDA), U1.28 (VDD), U1.50 (VDD), U1.75 (VDD), U1.100 (VDD), U4.2 (VO)
+5V: C8.2, C9.2, C12.1, C13.1, C16.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J6.5, L1.2, U2.16 (VCC), U3.4 (FB), U4.3 (VI)
+12V: D2.2 (A), J5.1
/BOOT0: R5.2, R7.2, U1.94 (BOOT0)
/BOOT1: R6.1, U1.37 (PB2)
/CH340G_D+: J1.A6 (D+), J1.B6 (D+), U2.5 (UD+)
/CH340G_D-: J1.A7 (D-), J1.B7 (D-), U2.6 (UD-)
/JTCK: J3.9 (TCK/SWDCLK), J6.1, U1.76 (PA14)
/JTDI: J3.5 (TDI), U1.77 (PA15)
/JTDO: J3.13 (TDO/SWO), U1.89 (PB3)
/JTMS: J3.7 (TMS/SWDIO), J6.2, U1.72 (PA13)
/JTRST: J3.3 (~TRST), U1.90 (PB4)
/PA9: J2.2, U1.68 (PA9)
/PA10: J2.1, U1.69 (PA10)
/RESET: C10.1, D1.2 (A), J3.15 (~SRST), R1.2, SW1.2, U1.14 (NRST)
/USART1_Rx: J2.3, U2.2 (TXD)
/USART1_Tx: J2.4, U2.3 (RXD)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.1, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, D3.2 (A), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J3.4 (GND), J3.6 (GND), J3.8 (GND), J3.10 (GND), J3.12 (GND), J3.14 (GND), J3.16 (GND), J3.18 (GND), J3.20 (GND), J4.5, J4.6, J5.2, J6.3, SW1.1, U1.10 (VSS), U1.19 (VSSA), U1.20 (VREF-), U1.27 (VSS), U1.49 (VSS), U1.74 (VSS), U1.99 (VSS), U2.1 (GND), U3.3 (GND), U3.5 (~ON/OFF), U4.1 (GND)
unnamed: D1.1 (K), Q1.3 (C), R3.1
unnamed: C15.1, D2.1 (K), U3.1 (VIN)
unnamed: D3.1 (K), L1.1, U3.2 (OUT)
unnamed: J4.3, R6.2
unnamed: J4.4, R7.1
unnamed: Q1.2 (B), R2.2
unnamed: Q1.1 (E), R4.1, U2.14 (~RTS)
unnamed: Q2.2 (B), R4.2
unnamed: Q2.3 (C), R5.1
unnamed: C3.1, U1.8 (PC14), Y2.2
unnamed: C4.1, U1.9 (PC15), Y2.1
unnamed: C2.1, U1.12 (RCC_OSC_IN), Y1.1
unnamed: C1.1, U1.13 (RCC_OSC_OUT), Y1.2
unnamed: C7.1, U2.4 (V3)
unnamed: C5.1, U2.7 (XI), Y3.2
unnamed: C6.1, U2.8 (XO), Y3.1
unnamed: R2.1, U2.12 (~DCD)

Notes on the sheet:
串口下载调试部分

Board: 2 copper layers, 100.0 x 100.0 mm, 43 parts (0 on the bottom side), 35 nets.
